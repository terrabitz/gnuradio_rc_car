<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>current_dir</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>down</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>down_left</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>down_right</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>left</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>right</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_length</value></param>
<param><key>value</key><value>532e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq</value></param>
<param><key>value</key><value>49.86e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>up</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>up_left</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>up_right</value></param>
<param><key>value</key><value>False</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/root/Documents/Wireless_Lab/captures/car_recreation.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>target_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


def convert_dir_to_num_dashes(dir_string):
    dir_to_dashes = {
        "UP": 10,
        "DOWN": 40,
        "LEFT": 64,
        "RIGHT": 58,
        "UP_LEFT": 34,
        "UP_RIGHT": 28,
        "DOWN_LEFT": 46,
        "DOWN_RIGHT": 52,
    }

    if dir_string not in dir_to_dashes.keys():
        raise KeyError('String ' + dir_string + ' is not an acceptable direction string')

    return dir_to_dashes[dir_string]

def convert_dir_booleans_to_dir_string(up, down, left, right, up_left, up_right, down_left, down_right):
    if up:
       return "UP"
    if down:
       return "DOWN"
    if left:
       return "LEFT"
    if right:
       return "RIGHT"
    if up_left:
       return "UP_LEFT"
    if up_right:
       return "UP_RIGHT"
    if down_left:
       return "DOWN_LEFT"
    if down_right:
       return "DOWN_RIGHT"

    return ""


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sample_rate=1e6, symbol_length=532e-6, up=False, down=False, left=False, right=False, up_left=False, up_right=False, down_left=False, down_right=False):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='RC Car Controller',   # will show up in GRC
            in_sig=[],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.up = up
    	self.down = down
    	self.left = left
    	self.right = right
    	self.up_left = up_left
    	self.up_right = up_right
    	self.down_left = down_left
    	self.down_right = down_right

        symbol_repeats = int(sample_rate * symbol_length)

        long_dash = [1,1,1,0]
        short_dash = [1,0]

        self.long_dash_repeated = []
        for i in long_dash:
            self.long_dash_repeated.extend([i]*symbol_repeats)

        self.short_dash_repeated = []
        for i in short_dash:
            self.short_dash_repeated.extend([i]*symbol_repeats)

        self.current_tx_bits = []

    def _create_vector(self):
        dir_string = convert_dir_booleans_to_dir_string(self.up, self.down, self.left, self.right, self.up_left, self.up_right, self.down_left, self.down_right)
        num_dashes = convert_dir_to_num_dashes(dir_string)

        vector = self.long_dash_repeated*4 + self.short_dash_repeated*num_dashes
        return vector

    def _should_transmit(self):
        return self.up or self.down or self.left or self.right or self.up_left or self.up_right or self.down_left or self.down_right

    def work(self, input_items, output_items):
        """
        Output the proper bit stream depending on the current direction
        """
    	output_items[0].fill(0)
        len_output_items = len(output_items[0])
        if self._should_transmit():
            # print(output_items)
            # print(output_items[0])
            # output_items[0] = self._create_vector()
            while len(self.current_tx_bits) &lt;= len_output_items:
                self.current_tx_bits.extend(self._create_vector())

            output_bits = self.current_tx_bits[0:len_output_items]
            # print(output_bits)
            self.current_tx_bits = self.current_tx_bits[len_output_items:]
            for index, bit in enumerate(output_bits):
                output_items[0][index] = bit
        else:
            del self.current_tx_bits[:]

        # print(output_items[0])
        return len(output_items[0])
</value></param>
<param><key>down_left</key><value>down_left</value></param>
<param><key>down_right</key><value>down_right</value></param>
<param><key>down</key><value>down</value></param>
<param><key>left</key><value>left</value></param>
<param><key>right</key><value>right</value></param>
<param><key>sample_rate</key><value>target_rate</value></param>
<param><key>symbol_length</key><value>symbol_length</value></param>
<param><key>up_left</key><value>up_left</value></param>
<param><key>up_right</key><value>up_right</value></param>
<param><key>up</key><value>up</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>target_freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>hackrf,buffers=2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>target_rate*interpolation</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>target_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>interpolation</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
